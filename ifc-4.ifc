Properties of the parts of a building model (IFC4)

# File
Description: Klemmenleiste, max. 8 Raumthermostate und 16 Stellantriebe, IP20, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: DA480520, Klemmenleiste, max. 8 Raumthermostate und 16 Stellantriebe, IP20
In: Raum
Description: Dieses Gerät wurde speziell zur Verdrahtung von 230 V~ Einzelraum-Temperaturreglern mit den zugehörigen Ventilstellantrieben zur ortsfesten Montage entwickelt. Die Klemmenleiste ist sowohl für Heizungsregler mit oder ohne ECO-Funktion als auch für Heiz-/Kühlregler mit integriertem Heiz-/Kühlumschalter geeignet. Durch Verwendung von einem Uhrenregler oder einer externen Schaltuhr kann eine Master-Slave-Regelung gebildet werden. An diese Klemmenleiste können, abhängig vom verwendeten Regler, Stellantriebe mit dem Wirksinn NC (normally closed) oder NO (normally open) angeschlossen werden.; Classification: EC010057 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: DA480520; ModelLabel: VOOPL-318.178; GlobalTradeItemNumber: 4050528073778; ProductURL: https://alre.de/produkt_DA480520
Pset_Specification - NominalLength: 0.255 m; NominalWidth: 0.1 m; NominalDepth: 0.0615 m; NetWeight: 0.381
Pset_ALRE_ETIM_Properties - Breite: 255; Höhe: 100; Tiefe: 61.5; Versorgungsspannung: 230; Ausgangsspannung: 230; Schutzart (IP): IP20; Max. Spannung der Kontakte: 230; Anzahl der Kanäle/Zone: 8; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010057; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-DA480520.pdf
